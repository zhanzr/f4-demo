/* OV7670 register table (VGA 640x480 RGB565, no-FIFO recipe) + color-bar.
 * Matches app/ov7670_to_lcd (iwatake2222 + OpenMV VGA frame values):
 * COM7=0x04, RGB444 off, COM15=0xD0, COM3=0x00, COM14=0x00,
 * HSTART/HSTOP/HREF/VSTART/VSTOP/VREF per frame_control(158,14,10,490),
 * COM13=0x80 gamma, COM16=0x38. */

#include "ov7670_regs.h"
#include "sccb_bitbang.h"

static const uint8_t reg_tbl[][2] =
{
    {0x12, 0x04}, {0x8c, 0x00}, {0x40, 0xd0}, {0x3a, 0x0c},
    {0x0c, 0x00}, {0x3e, 0x00}, {0x70, 0x3a}, {0x71, 0x35},
    {0x72, 0x11}, {0x73, 0xf0}, {0xa2, 0x02},
    {0x32, 0x36}, {0x17, 0x13}, {0x18, 0x01}, {0x19, 0x02},
    {0x1a, 0x7a}, {0x03, 0x0a}, {0x15, 0x00}, {0x11, 0x00},
    {0x3d, 0x80}, {0x41, 0x38},
    {0x7a, 0x20}, {0x7b, 0x1c}, {0x7c, 0x28}, {0x7d, 0x3c},
    {0x7e, 0x55}, {0x7f, 0x68}, {0x80, 0x76}, {0x81, 0x80},
    {0x82, 0x88}, {0x83, 0x8f}, {0x84, 0x96}, {0x85, 0xa3},
    {0x86, 0xaf}, {0x87, 0xc4}, {0x88, 0xd7}, {0x89, 0xe8},
    {0x13, 0xe0}, {0x00, 0x00}, {0x10, 0x00}, {0x0d, 0x00},
    {0x14, 0x20}, {0xa5, 0x05}, {0xab, 0x07}, {0x24, 0x75},
    {0x25, 0x63}, {0x26, 0xa5}, {0x9f, 0x78}, {0xa0, 0x68},
    {0xa1, 0x03}, {0xa6, 0xdf}, {0xa7, 0xdf}, {0xa8, 0xf0},
    {0xa9, 0x90}, {0xaa, 0x94}, {0x13, 0xe5}, {0x0e, 0x61},
    {0x0f, 0x4b}, {0x16, 0x02}, {0x1e, 0x31}, {0x21, 0x02},
    {0x22, 0x91}, {0x29, 0x07}, {0x33, 0x0b}, {0x35, 0x0b},
    {0x37, 0x1d}, {0x38, 0x71}, {0x39, 0x2a}, {0x3c, 0x78},
    {0x4d, 0x40}, {0x4e, 0x20}, {0x69, 0x5d}, {0x6b, 0x40},
    {0x74, 0x19}, {0x8d, 0x4f}, {0x8e, 0x00}, {0x8f, 0x00},
    {0x90, 0x00}, {0x91, 0x00}, {0x92, 0x00}, {0x96, 0x00},
    {0x9a, 0x80}, {0xb0, 0x84}, {0xb1, 0x0c}, {0xb2, 0x0e},
    {0xb3, 0x82}, {0xb8, 0x0a}, {0x43, 0x14}, {0x44, 0xf0},
    {0x45, 0x34}, {0x46, 0x58}, {0x47, 0x28}, {0x48, 0x3a},
    {0x59, 0x88}, {0x5a, 0x88}, {0x5b, 0x44}, {0x5c, 0x67},
    {0x5d, 0x49}, {0x5e, 0x0e}, {0x64, 0x04}, {0x65, 0x20},
    {0x66, 0x05}, {0x94, 0x04}, {0x95, 0x08}, {0x6c, 0x0a},
    {0x6d, 0x55}, {0x4f, 0x80}, {0x50, 0x80}, {0x51, 0x00},
    {0x52, 0x22}, {0x53, 0x5e}, {0x54, 0x80}, {0x09, 0x03},
    {0x6e, 0x11}, {0x6f, 0x9f}, {0x55, 0x00}, {0x56, 0x40},
    {0x57, 0x80},
};

uint8_t OV7670_ApplyConfig(void)
{
    /* soft reset */
    if (SCCB_BB_WriteReg(0x12, 0x80)) return 1;
    {
        volatile uint32_t w;
        for (w = 0; w < 2000000; w++) { }   /* ~50 ms */
    }
    for (uint32_t i = 0; i < (sizeof(reg_tbl) / sizeof(reg_tbl[0])); i++)
    {
        if (SCCB_BB_WriteReg(reg_tbl[i][0], reg_tbl[i][1])) return 2;
    }
    return 0;
}

void OV7670_OpenMvRgbTweak(void)
{
    /* COM15 = 0xD0: RGB565 + output range 00..FF (full).
     * (ALIENTEK table ended with 0x10 = RGB565 + 10..F0 limited range -
     *  that's the dark/washed "color curve", and 0x8217 = 0x82 0x17 is not
     *  a valid RGB565 bar.) */
    SCCB_BB_WriteReg(0x40, 0xD0);

    /* OpenMV: rewrite CLKRC last for clean RGB565. */
    SCCB_BB_WriteReg(0x11, 0x00);
}

void OV7670_ColorBarOn(void)
{
    /* Only toggle bit7 of SCALING_YSC (color-bar enable); preserve the
     * VGA scaling factors (XSC=0x3A, YSC=0x35) - clobbering them with
     * QVGA values corrupts the row geometry (the diagonal bug). */
    uint8_t xsc = SCCB_BB_ReadReg(0x70);
    uint8_t ysc = SCCB_BB_ReadReg(0x71);
    SCCB_BB_WriteReg(0x70, (uint8_t)(xsc & 0x7FU));
    SCCB_BB_WriteReg(0x71, (uint8_t)((ysc & 0x7FU) | 0x80U));
}

void OV7670_ColorBarOff(void)
{
    uint8_t xsc = SCCB_BB_ReadReg(0x70);
    uint8_t ysc = SCCB_BB_ReadReg(0x71);
    SCCB_BB_WriteReg(0x70, (uint8_t)(xsc & 0x7FU));
    SCCB_BB_WriteReg(0x71, (uint8_t)(ysc & 0x7FU));
}